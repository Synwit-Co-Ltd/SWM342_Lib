# Keil uVision project RT-Thread.uvprojx, settings and files
target SWM342 (6160000::V6.16::ARMCLANG)
  device: SWM342xE Synwit
  pack: Synwit.SWM32_DFP.1.18.1
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: RT-Thread
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\SWM342_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM342_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM342_StdPeriph_Driver\CSL\SWM342_StdPeriph_Driver;.\APP;.\APP\rt-thread\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ./app/: main.c
    ./APP/: board.c
  group RT-Thread
    ./APP/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread\Port
    ./APP/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group CSL\StdPD
    ../../SWM342_StdPeriph_Driver/CSL/SWM342_StdPeriph_Driver/: SWM342_adc.c SWM342_exti.c SWM342_gpio.c SWM342_i2c.c SWM342_pwm.c SWM342_timr.c SWM342_uart.c SWM342_wdt.c SWM342_dma.c SWM342_flash.c SWM342_port.c SWM342_spi.c SWM342_can.c SWM342_crc.c SWM342_lcd.c SWM342_rtc.c
  group CSL\CMSIS
    ../../SWM342_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM342.c
    ../../SWM342_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM342.s
