# Keil uVision project uCOS-II.uvprojx, settings and files
target SWM342 (6160000::V6.16::ARMCLANG)
  device: SWM342xE Synwit
  pack: Synwit.SWM32_DFP.1.18.1
  cpu: CPUTYPE("Cortex-M33") CLOCK(12000000) ESEL ELITTLE
  output: uCOS-II
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\SWM342_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM342_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM342_StdPeriph_Driver\CSL\SWM342_StdPeriph_Driver;.\APP;.\APP\uCOS;.\APP\uCOS\Ports\ARMv7-M\GNU
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/Ports/ARMv7-M/: os_cpu_c.c
    ./APP/uCOS/Ports/ARMv7-M/GNU/: os_cpu_a.S
  group CSL\StdPD
    ../../SWM342_StdPeriph_Driver/CSL/SWM342_StdPeriph_Driver/: SWM342_adc.c SWM342_exti.c SWM342_gpio.c SWM342_i2c.c SWM342_pwm.c SWM342_timr.c SWM342_uart.c SWM342_wdt.c SWM342_dma.c SWM342_flash.c SWM342_port.c SWM342_spi.c SWM342_can.c SWM342_crc.c SWM342_lcd.c SWM342_rtc.c
  group CSL\CMSIS
    ../../SWM342_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM342.c
    ../../SWM342_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM342.s
