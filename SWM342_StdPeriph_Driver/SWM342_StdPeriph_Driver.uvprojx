# Keil uVision project SWM342_StdPeriph_Driver.uvprojx, settings and files
target SWM342 (6160000::V6.16::ARMCLANG)
  device: SWM342xE Synwit
  pack: Synwit.SWM32_New.0.0.2
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: SWM342_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM342_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM342_StdPeriph_Driver/: SWM342_port.c SWM342_gpio.c SWM342_exti.c SWM342_timr.c SWM342_uart.c SWM342_adc.c SWM342_dma.c SWM342_i2c.c SWM342_pwm.c SWM342_can.c SWM342_spi.c SWM342_lcd.c SWM342_flash.c SWM342_crc.c SWM342_rtc.c SWM342_wdt.c SWM342_cordic.c SWM342_sleep.c SWM342_usbd.c SWM342_div.c SWM342_sdio.c SWM342_sdram.c SWM342_dac.c SWM342_jpeg.c SWM342_dma2d.c SWM342_iofilt.c SWM342_qei.c SWM342_sfc.c SWM342_usbh.c SWM342_canfd.c SWM342_cache.c SWM342_dcmi.c SWM342_sra.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM342.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM342.s
